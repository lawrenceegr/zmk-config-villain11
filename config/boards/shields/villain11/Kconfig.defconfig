## config/boards/shields/villain11/Kconfig.defconfig
```kconfig
if SHIELD_VILLAIN11

config ZMK_KEYBOARD_NAME
    default "villain11"
    
endif
```
